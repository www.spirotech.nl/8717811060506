Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC250FM_INT-EN.ifc
Time: 2025-08-05T18:33:32+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2144745_3
Port_2144745_4
Port_2144745_7
Port_2144745_8

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC-M_INT-EN:XC250FM, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC-M_INT-EN:XC250FM:2144745
In: F00
Type - Material: Color RGB 040-040-040, Color RGB 168-128-048, Color RGB 198-000-000, Color RGB 128-128-128, Color RAL 1003
Type - Other - Category: Pipe Accessories; Base Flange: 22.5 mm; Base Flange Radius: 136.5 mm; Bottom Geometry Height: 95 mm; Brackets Height: 5 mm; Chamfer Radius: 101.6 mm; Cone Flange: 28 mm; Cone Flange Radius Bottom: 158.5 mm; Cone Flange Radius Top: 136.5 mm; Distance Between Brackets: 350 mm; DN: 250 mm; Drain Offset: 131 mm; Drain Radius: 16.85 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC-M_INT-EN; Flange Body: 23 mm; Flange Body Diameter: 405 mm; Flange Body Radius: 202.5 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 160 mm; Front Bracket Offset 2: 79.5 mm; h: 835 mm; h1: 1100 mm; h2: 935 mm; h3: 100 mm; Inner Diameter Ring: 6 mm; OD: 273 mm; Outer Diameter Bracket: 26 mm; Service Space Depth: 511 mm; Service Space Height: 2870 mm; Type Value: 8; Upper Geometry Radius: 12 mm; Upper Side Height: 839 mm; Width: 230 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 250 mm; D: 508 mm; H: 2870 mm; L: 737 mm; LF: 890 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Low-los Header with Deaerator & dirt separator - Steel - Flange DN250 - Magnet; Article Type: XC250FM; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low-los Header with Deaerator & dirt separator - Steel - Flange DN250 - Magnet; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.19; GLN: 8717811000007; GTIN: 8717811060520; Manufacturer: Spirotech; Manufacturer Art. No.: XC250FM; Manufacturer URL: https://www.spirotech.com/8717811060520; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: XC250FM; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: XC250FM; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.0015 m3/s; Pressure Stage: 16; Volume: 0 m3; Weight: 372 kg
Type - Mechanical - Flow - Pressure Drop: 0 Pa
Type - Visibility - Additional Drain: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: XC250FM; sets with these values: 2
Other - Additional Drain Offset: 50 mm; Bottom Clearance Safe: 100 mm; Connectors Length: 890 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC-M_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC-M_INT-EN: XC250FM; L Safe: 737 mm; Top Clearance Safe: 0 mm; Type: XC250FM; Type Id: 2144720
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 4.61576 m2; Maximum Size: 250 mm; Minimum Size: 250 mm; Volume: 0.59432 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow In 2: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 75 mm; Counter Flange: no; Counter Flange Safe: no; Flange: yes; Service Space: no; Top Clearance: 0 mm
Insulation - Insulation Thickness: 0 mm
